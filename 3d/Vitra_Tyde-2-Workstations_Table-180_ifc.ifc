Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2023-11-23T01:30:31
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20191106_1200(x64) - Exporter 20.2.1.1 - Alternate UI 20.2.1.1
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Nov 23 01:30:31 2023 * Host: DESKTOP-JLKK7TQ * Database: C:\Users\vladb\AppData\Local\Temp\4cd241f8-d850-4ce6-8a37-90f0a535371d\34c7565c-c568-408f-9419-07ee3562552d\ifc * Database version: 5507 * Database creation date: Thu Nov 23 01:30:29 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Nov 23 01:30:29 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Nov 23 01:30:29 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Pset_ProductRequirements - Category: Project Information
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Pset_AirSideSystemInformation - Name: Level 1
Pset_ProductRequirements - Name: Level 1; Category: Levels
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFurnishingElement: Tyde 2 office table 180x80 cm, Furniture_Office-Desks&Tables_Vitra_Tyde-2-Workstations_Table-180_rfa:Tyde 2 office table 180x80 cm:430030
In: Level 1
Type - Material: 52 soft light, 52 soft light powder-coated, Rubber, Black, 01 basic dark, Table light oak
Type - Constraints - Default Elevation: 0 mm
Type - General - Author: BIMStone; BIMObjectName: Furniture_Office-Desks&Tables_Vitra_Tyde-2-Workstations_Table-180; ManufacturerName: Vitra; ManufacturerURL: https://www.vitra.com/; NBSDescription: Office tables; NBSReference: 45-35-20/340; ProductInformation: n/a; Revision: 1; Uniclass2: Pr_40_50_21_60; Uniclass2015Description: Office tables; Uniclass2015Reference: Pr_40_50_21_60; Version: 2; VersionDate: 13/11/2023
Type - Identity Data - Collection: Tyde; Cost: 0; Designer: Ronan & Erwan Bouroullec; Manufacturer: Vitra; Model: Tyde 2 office table 180x80 cm; OmniClass Number: 23.40.20.14.17; OmniClass Title: Residential Tables and Cabinets; Type Name: Tyde 2 office table 180x80 cm; URL: https://www.vitra.com/en-un/office/product/details/tyde-2-workstations
Type - Other - Category: Furniture; AccessibilityPerformance: n/a; AssetType: Movable; Brand: Vitra; CodePerformance: n/a; Color: Various; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: Furniture_Office-Desks&Tables_Vitra_Tyde-2-Workstations_Table-180_rfa; Features: n/a; Finish: n/a; Grade: n/a; Material: Melanine, metal & textile.; ModelNumber: n/a; ModelReference: n/a; Name: Tyde-2-Workstations_Table-180; ReplacementCost: n/a; Shape: Sculptured; Size: 1800x800x740 mm; SustainabilityPerformance: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Type - Pset_ElementShading - Color: Various
Type - Pset_ManufacturerTypeInformation - ModelReference: n/a; Manufacturer: Vitra
Type - Pset_ProductRequirements - Name: Tyde-2-Workstations_Table-180; Category: Furniture
Type - Pset_QuantityTakeOff - Reference: Tyde 2 office table 180x80 cm
Pset_ManufacturerOccurrence - BarCode: n/a; SerialNumber: n/a
Constraints - Base_Stand: no; CableGuide_Cover: no; CableGuide_Tray: no; CableTray: no; Elevation from Level: 0 mm; Handset_Display: no; Host: Level : Level 1; Level: Level: Level 1; Moves With Nearby Elements: no; Offset from Host: 0 mm; Screen_ForClip: no; Screen_Single: no; TableTopCableOutlet_Both: no; TableTopCableOutlet_Left: no; TableTopCableOutlet_Right: no
Construction - CastorsVisibility: yes
Dimensions - Area: 3.36401 m2; Volume: 1.06561 m3
Materials and Finishes - BaseMaterial: 52 soft light; CableOutletMaterial: 01 basic dark; CableTrayMaterial: 12 deep black; FleeceMaterial: Textile fleece pebble grey 01; ScreenMaterial: Textile laser yellow pastel green 23; TableTopMaterial: Table light oak
Other - AssetIdentifier: n/a; Barcode: n/a; Family: Furniture_Office-Desks&Tables_Vitra_Tyde-2-Workstations_Table-180_rfa: Tyde 2 office table 180x80 cm; Family and Type: Furniture_Office-Desks&Tables_Vitra_Tyde-2-Workstations_Table-180_rfa: Tyde 2 office table 180x80 cm; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: Furniture_Office-Desks&Tables_Vitra_Tyde-2-Workstations_Table-180_rfa: Tyde 2 office table 180x80 cm; Type Id: Furniture_Office-Desks&Tables_Vitra_Tyde-2-Workstations_Table-180_rfa: Tyde 2 office table 180x80 cm; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
Text - MetaProperties_Base: Table; MetaProperties_CableGuide: not included; MetaProperties_CableTray: not included; MetaProperties_Positioning: not included; MetaProperties_Screen: not selected; MetaProperties_TableTopVersion: without cable outlet
