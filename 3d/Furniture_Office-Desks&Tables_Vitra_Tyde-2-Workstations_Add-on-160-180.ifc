Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2021-06-24T17:11:01
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190510_1515(x64) - Exporter 18.3.3.18 - Alternate UI 18.3.3.18
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Jun 24 17:11:01 2021 * Host: Avocado-PC * Database: D:\Jocuri\TEMP\{87CBB5F2-09F1-4521-B5D8-75C37015EEE1}\ifc * Database version: 5507 * Database creation date: Thu Jun 24 17:10:59 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Jun 24 17:11:00 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Jun 24 17:11:00 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFurnishingElement: Tyde 2 add-on table for cluster 160/180, Furniture_Office-Desks&Tables_Vitra_Tyde-2-Workstations_Add-on-160-180:Tyde 2 add-on table for cluster 160/180:422226
In: Level 1
Type - Material: Table light oak, 01 basic dark, 52 soft light
Type - Dimensions - NominalDepth: 979.543 mm; NominalLength: 1720 mm
Type - General - Author: BIMStone; BIMObjectName: Furniture_Office-Desks&Tables_Vitra_Tyde-2-Workstations_Add-on-160-180; ManufacturerName: Vitra; ManufacturerURL: https://www.vitra.com/; NBSDescription: Office tables; NBSReference: 45-35-20/340; ProductInformation: n/a; Revision: n/a; Uniclass2: Pr_40_50_21_60; Uniclass2015Description: Office tables; Uniclass2015Reference: Pr_40_50_21_60; Version: 1; VersionDate: 16/06/2021
Type - Identity Data - Collection: Tyde; Cost: 0; Designer: Ronan & Erwan Bouroullec; Manufacturer: Vitra; Model: Tyde 2 add-on table for cluster 160/180; OmniClass Number: 23.40.20.14.17; OmniClass Title: Residential Tables and Cabinets; Type Name: Tyde 2 add-on table for cluster 160/180; URL: https://www.vitra.com/en-un/office/product/details/tyde-2-workstations
Type - Other - Category: Furniture; AccessibilityPerformance: n/a; AssetType: Movable; Brand: Vitra; CodePerformance: n/a; Color: Various; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: Furniture_Office-Desks&Tables_Vitra_Tyde-2-Workstations_Add-on-160-180; Features: n/a; Finish: n/a; Grade: n/a; Material: Melanine, metal & textile.; ModelNumber: n/a; ModelReference: n/a; Name: Tyde-2-Workstations_Add-on-160-180; ReplacementCost: n/a; Shape: Sculptured; Size: 1720x800x740 mm; SustainabilityPerformance: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Pset_ManufacturerTypeInformation - ModelReference: n/a; Manufacturer: Vitra
Constraints - Base_Stand: no; CableGuide_Cover: no; CableGuide_Tray: no; CableTray: no; Handset_Display: no; Host: Level : Level 1; Level: Level: Level 1; Moves With Nearby Elements: no; Offset: 0 mm; TableTopCableOutlet_Both: no; TableTopCableOutlet_Left: no; TableTopCableOutlet_Right: no
Dimensions - Area: 3.68248 m2; NominalHeight: 740 mm; Volume: 1.24676 m3
Materials and Finishes - BaseMaterial: 52 soft light; CableOutletMaterial: 01 basic dark; CableTrayMaterial: 12 deep black; FleeceMaterial: Textile fleece pebble grey 01; ScreenMaterial: Textile laser yellow pastel green 23; TableTopMaterial: Table light oak
Other - AssetIdentifier: n/a; Barcode: n/a; Family: Furniture_Office-Desks&Tables_Vitra_Tyde-2-Workstations_Add-on-160-180: Tyde 2 add-on table for cluster 160/180; Family and Type: Furniture_Office-Desks&Tables_Vitra_Tyde-2-Workstations_Add-on-160-180: Tyde 2 add-on table for cluster 160/180; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: Furniture_Office-Desks&Tables_Vitra_Tyde-2-Workstations_Add-on-160-180: Tyde 2 add-on table for cluster 160/180; Type Id: Furniture_Office-Desks&Tables_Vitra_Tyde-2-Workstations_Add-on-160-180: Tyde 2 add-on table for cluster 160/180; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
Text - MetaProperties_Base: Table; MetaProperties_CableGuide: not included; MetaProperties_CableTray: not included; MetaProperties_Positioning: not included; MetaProperties_TableTopVersion: without cable outlet
